Commit message: Kinodynamic experiment setup

File: spline_rl/urdf/iiwa_cup.urdf (robot description, URDF)
Before this commit: robot iiwa, 11 links, 10 joints
Links:
- link F_link_cup: mass 14.0 -> 12.0
